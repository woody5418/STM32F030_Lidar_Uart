# Keil uVision project STM32F103_Home.uvprojx, settings and files
target Home_test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_Home +hex
  c flags: OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\User;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib\inc;..\APPS;..\HARDWARE\USART1;..\HARDWARE\TIMER2;..\HARDWARE\TIMER4;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\USART2;..\HARDWARE\TIMER3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c includes.h
  group HardWare
    ../HARDWARE/TIMER3/: timer3.c
    ../HARDWARE/TIMER4/: timer4.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/LED/: led.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
